options:
  parameters:
    generate_options: qt_gui
    id: Flowgraphs
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '320000'
  states: {}
- name: sps
  id: variable
  parameters:
    value: '1'
  states: {}
- name: variable_rrc_filter_taps_0
  id: variable_rrc_filter_taps
  parameters:
    alpha: '0.35'
    gain: sps
    ntaps: 11*sps
    samp_rate: samp_rate
    sym_rate: samp_rate/sps
  states: {}
- name: analog_random_uniform_source_x_0
  id: analog_random_uniform_source_x
  parameters:
    maximum: '4'
    minimum: '0'
    seed: '0'
    type: byte
  states: {}
- name: blocks_vector_source_x_0
  id: blocks_vector_source_x
  parameters:
    repeat: 'True'
    type: byte
    vector: (0, 0, 0, 0, 0)
  states: {state: disabled}
- name: interp_fir_filter_xxx_0
  id: interp_fir_filter_xxx
  parameters:
    interp: sps
    taps: variable_rrc_filter_taps_0
    type: ccc
  states: {}
- name: pi_modulators_pi_2_bpsk_0
  id: pi_modulators_pi_2_bpsk
  parameters: {}
  states: {state: disabled}
- name: pi_modulators_pi_4_qpsk_0
  id: pi_modulators_pi_4_qpsk
  parameters: {}
  states: {}
- name: qtgui_const_sink_x_0
  id: qtgui_const_sink_x
  parameters:
    grid: 'True'
    size: '1024'
    style1: '1'
    type: complex
  states: {}

connections:
- [analog_random_uniform_source_x_0, '0', pi_modulators_pi_2_bpsk_0, '0']
- [analog_random_uniform_source_x_0, '0', pi_modulators_pi_4_qpsk_0, '0']
- [blocks_vector_source_x_0, '0', pi_modulators_pi_4_qpsk_0, '0']
- [interp_fir_filter_xxx_0, '0', qtgui_const_sink_x_0, '0']
- [pi_modulators_pi_2_bpsk_0, '0', interp_fir_filter_xxx_0, '0']
- [pi_modulators_pi_4_qpsk_0, '0', interp_fir_filter_xxx_0, '0']

metadata:
  file_format: 1
